# Keil uVision project HelloWorld.uvprojx, settings and files
target Target Hello (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HelloWorld
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: HSE_VALUE=8000000. USE_HAL_DRIVER. STM32F407xx. ARM_MATH_CM4. __FPU_PRESENT = 1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:Startup 2.6.0
